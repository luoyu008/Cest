# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\Library;.\Start;.\System;.\User;.\Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h DCmotors.c DCmotors.h output.h output.c input.h input.c TIM2interrupt.h TIM2interrupt.c ADCONE.h ADCONE.c ADCMORE.h ADCMORE.c TIM3.h TIM3.c TIM2.h TIM2.c ADC2.h ADC2.c DMA1.c DMA1.h
    ./Hardware/: DMAARR.c DMAARR.h
  group Hardware
    ./Hardware/: buzzer.c BUZZER.h LIGHT.h light.c OLED_Font.h OLED.c OLED.h Tbsensor.c Tbsensor.h Delay.c Delay.h KEY.c KEY.h Encoderspeed.c Encoderspeed.h Serial.c Serial.h SerialReceive.h SerialReceive.c Bluetooth.h Bluetooth.c SG90.c SG90.h IIC.h IIC.c MPU6050ruanjian.h MPU6050_Reg.h MPU6050yingjian.c MPU6050yingjian.h IICyingjian.c IICyingjian.h MPU6050ruanjian.c SPIruanjian.c SPIruanjian.h W25Q64ruanjian.h W25Q64ruanjian.c W25Q64ADDRESS.h SPIyingjian.c SPIyingjian.h RTC.h RTC.c
  group UsER
    ./User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ./: main.c
