# Keil uVision project 1.uvprojx, settings and files
target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../CORE/Src/: CLED.c KEY.c DELAY.c MYLED.c EXIT.c IICruanjian.c OLED.h USART.c IWDG.c WWDG.c TIM6.c PWMMotor.c SG90.c ICmeasure.c Rencoder.c TIMRencoder.c TIMPULSEcount.c AdvanceTimPwm.c DifPhasePwm.c AdvancedTimCODTCtrl.c ADVANCEDTIMICPWM.c RTCRTClock.c ADC.c MPU6050ruanjianIIC.c IICruanjianMPU6050.c IICyingjian.c MPU6050IICyingjian.c SPIyingjian.c W25Q64SPIyingjian.c SPIruanjian.c W25Q64SPIruanjian.c SmartRubbish.c hcsr501.c
    ../CORE/Inc/: CLED.h KEY.h DELAY.h MYLED.h EXIT.h IICruanjian.h OLED.c USART.h IWDG.h WWDG.h TIM6.h PWMMotor.h SG90.h ICmeasure.h Rencoder.h TIMRencoder.h TIMPLUSEcount.h AdvanceTimPwm.h DifPhasePwm.h AdvancedTimCODTCtrl.h ADVANCEDTIMICPWM.h RTCRTClock.h ADC.h MPU6050ruanjianIIC.h IICruanjianMPU6050.h MPU6050_Reg.h IICyingjian.h MPU6050IICyingjian.h SPIyingjian.h W25Q64SPIyingjian.h W25Q64ADDRESS.h SPIruanjian.h W25Q64SPIruanjian.h SmartRubbish.h hcsr501.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_spi.c stm32f1xx_hal_sd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
